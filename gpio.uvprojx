# Keil uVision project gpio.uvprojx, settings and files
target gpio (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.4.2
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group src
    ./src/: Startup.s main.c itmr.c misc.c button.c
  group inc
    ./inc/: core_cm1.c core_cm1.h opora.h opora_adc_defs.h opora_arinc429r_defs.h opora_arinc429t_defs.h opora_bkp_defs.h opora_can_defs.h opora_dac_defs.h opora_dma_defs.h opora_eeprom_defs.h opora_ethernet_defs.h opora_ext_bus_cntrl_defs.h opora_iwdg_defs.h opora_mil_std_1553_defs.h opora_port_defs.h opora_power_defs.h opora_rst_clk_defs.h opora_spi_defs.h opora_sys_defs.h opora_timer_defs.h opora_uart_defs.h opora_usb_defs.h opora_wwdg_defs.h stdint.h itmr.h misc.h button.h
